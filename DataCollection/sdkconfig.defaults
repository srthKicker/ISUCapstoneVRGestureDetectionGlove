## DataCollection/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_ESP32_DEFAULT_CPU_FREQ_240=y
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_I2C_ENABLE=y
```
